# Keil uVision project AAM800_MCU.uvproj, settings and files
target AAM800_MCU (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AAM800_MCU
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Dev\inc;..\User\inc;..\Lib\inc;..\App\inc;..\System\inc;..\Malloc;..\Fatfs\exfuns;..\Fatfs\src;..\AudioCode\wav;..\AudioCode\mp3;..\AudioCode\mp3\helix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/src/: main.c system_stm32f4xx.c sys.c aam800_mcu_eval_init.c
  group Dev
    ../Dev/src/: dev_i2c.c dev_hmilcd.c dev_adc.c dev_cs8416.c
  group Lib
    ../Lib/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_adc.c
  group System
    ../System/src/: sys_base.c sys_delay.c sys_uart.c
  group Malloc
    ../Malloc/: malloc.c
  group Core
    ../Code/: startup_stm32f40_41xxx.s
  group Text
    ../Text/: version.txt
